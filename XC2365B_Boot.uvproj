# Keil uVision project XC2365B_Boot.uvproj, settings and files
target Target 1 (166/167)
  device: XC2365A-104F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE07FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCCFFFF) CLOCK(80000000) MOD167 MODV2
  output: XC2365B_Boot
  group Dave Files
    ./: Start_V3.A66 MAIN.c SCS.c IO.c
  group User Files
    ./: Bootroom.C pflash.c irq_redir.a66
